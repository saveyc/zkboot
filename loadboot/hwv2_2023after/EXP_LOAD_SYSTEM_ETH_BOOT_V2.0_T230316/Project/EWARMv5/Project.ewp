# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\Libraries\lwip_v1.3.2\src\include; ..\..\Libraries\lwip_v1.3.2\src\include\lwip; ..\..\Libraries\lwip_v1.3.2\src\include\netif; ..\..\Libraries\lwip_v1.3.2\src\include\ipv4; ..\..\Libraries\lwip_v1.3.2\src\include\ipv4\lwip; ..\..\Libraries\lwip_v1.3.2\port\STM32F2x7\Standalone; ..\..\Libraries\lwip_v1.3.2\port\STM32F2x7\arch; ..\..\Libraries\lwip_v1.3.2\port\STM32F2x7\; ..\inc; ..\..\Project\flash_if; ..\..\Project\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exp_load_ctrl_eth_boot_v2.2_20230316.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: Project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group ETHLib
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group FLASH_IF
    ../flash_if/: flash_if.c
  group FWlib
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group LwIP
    ../../Libraries/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Libraries/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Libraries/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../Libraries/lwip_v1.3.2/src/netif/: etharp.c
    ../../Libraries/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group USER
    ../src/: fun.c main.c netconf.c stm32f207.c stm32f2x7_eth_bsp.c stm32f2xx_it.c tftpserver.c udpclient.c
