# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; IAP_MODE_SYS
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: exp_io_ctrl_slave_test_230815.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: Project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group FWlib
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group USER
    ../src/: bsp.c can2_bus.c can_bus.c io.c main.c stm32f2xx_it.c usart1.c usart6.c
